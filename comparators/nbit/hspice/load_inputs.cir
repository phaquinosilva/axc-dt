Xa00 a0_in na0_in vdd1 inv M=4
Xa01 na0_in a0 vdd1 inv M=4
Xa10 a1_in na1_in vdd1 inv M=4
Xa11 na1_in a1 vdd1 inv M=4
Xa20 a2_in na2_in vdd1 inv M=4
Xa21 na2_in a2 vdd1 inv M=4
Xa30 a3_in na3_in vdd1 inv M=4
Xa31 na3_in a3 vdd1 inv M=4
Xa40 a4_in na4_in vdd1 inv M=4
Xa41 na4_in a4 vdd1 inv M=4
Xa50 a5_in na5_in vdd1 inv M=4
Xa51 na5_in a5 vdd1 inv M=4
Xa60 a6_in na6_in vdd1 inv M=4
Xa61 na6_in a6 vdd1 inv M=4
Xa70 a7_in na7_in vdd1 inv M=4
Xa71 na7_in a7 vdd1 inv M=4

Xb00 b0_in nb0_in vdd1 inv M=4
Xb01 nb0_in b0 vdd1 inv M=4
Xb10 b1_in nb1_in vdd1 inv M=4
Xb11 nb1_in b1 vdd1 inv M=4
Xb20 b2_in nb2_in vdd1 inv M=4
Xb21 nb2_in b2 vdd1 inv M=4
Xb30 b3_in nb3_in vdd1 inv M=4
Xb31 nb3_in b3 vdd1 inv M=4
Xb40 b4_in nb4_in vdd1 inv M=4
Xb41 nb4_in b4 vdd1 inv M=4
Xb50 b5_in nb5_in vdd1 inv M=4
Xb51 nb5_in b5 vdd1 inv M=4
Xb60 b6_in nb6_in vdd1 inv M=4
Xb61 nb6_in b6 vdd1 inv M=4
Xb70 b7_in nb7_in vdd1 inv M=4
Xb71 nb7_in b7 vdd1 inv M=4
